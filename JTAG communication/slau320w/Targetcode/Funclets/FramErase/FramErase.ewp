# IAR project FramErase.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: "..\..\SRecord\srec_cat.exe" "$TARGET_DIR$\$PROJ_FNAME$.txt" -ti_txt -Output "$PROJ_FNAME$.c" -c_array $PROJ_FNAME$_o -output_word -No-CONST
  XLINK.XclFile: C:\MSP430\replicator\Targetcode\Funclets\FramErase\config\lnk430F5438_obj.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    config/: lnk430F5438_obj.xcl
    ./: msp430fr57xx_FramErase.asm
