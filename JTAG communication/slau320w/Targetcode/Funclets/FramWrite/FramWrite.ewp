# IAR project FramWrite.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: "..\Bin\srec_cat.exe" "$TARGET_DIR$\$PROJ_FNAME$.txt" -ti_txt -Output "$PROJ_FNAME$.c" -c_array $PROJ_FNAME$_o -output_word -No-CONST
  XLINK.XclFile: CONFIG\lnk430F5438_obj.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    config/: lnk430F5438_obj.xcl
    ./: msp430fr57xx_FramWrite.asm
