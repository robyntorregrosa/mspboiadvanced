# IAR project Replicator430FR.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5437 MSP430F5437
  General.GStackSize2: 260
  General.GHeapSize2: 260
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5437.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../Replicator430FR/: Config430FR.h JSBW.c JTAGfunc430FR.c LowLevelFunc430Xv2.c LowLevelFunc430Xv2.h Replicator430FR.c
