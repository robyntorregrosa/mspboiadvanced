# IAR project Replicator430Xv2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5437 MSP430F5437
  General.GStackSize2: 260
  General.GHeapSize2: 260
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5437.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../Replicator430Xv2/: Config430Xv2.h JSBW.c JTAGfunc430Xv2.c LowLevelFunc430Xv2.c LowLevelFunc430Xv2.h Replicator430Xv2.c Target_Code_5xx_IAR.s43
