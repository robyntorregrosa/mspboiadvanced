# IAR project Replicator430X.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5437 MSP430F5437
  General.GStackSize2: 500
  General.GHeapSize2: 500
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5437.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Replicator430X/: Config430X.h Devices430X.c JTAGfunc430X.c LowLevelFunc430X.c Replicator430X.c Target_Code_IAR.s43
